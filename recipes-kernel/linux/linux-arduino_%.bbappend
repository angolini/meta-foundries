FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://wireguard.cfg"
